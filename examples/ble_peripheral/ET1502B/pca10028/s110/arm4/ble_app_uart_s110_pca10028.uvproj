# Keil uVision project ble_app_uart_s110_pca10028.uvproj, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ET1502_1231 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_DFU_APP_SUPPORTx BLE_STACK_SUPPORT_REQD ET1502B S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0  ENABLE_SIMPLE_UART ENABLE_NEW_BOARD
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\etDriver;..\..\..\etAlgSrc;..\..\..\etAlgSystem;..\..\..\etDisplay;..\..\..\etInclude;..\..\..\etProtocol;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\drivers_nrf\twi_master\incubated\config;..\..\..\..\..\..\components\drivers_nrf\twi_master\incubated
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../etDriver/: et_nrf_drv_wdt.c
    ../../../../../../components/drivers_nrf/twi_master/incubated/: twi_sw_master.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/bootloader_dfu/: bootloader_util.c dfu_app_handler.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group etDriver
    ../../../etDriver/: et_debug.c et_battery.c et_Spi_gpio.c etI2c.c etMotor.c etSpi.c sys_time.c etkeyboard.c etSimple_uart.c etVersion.c et_WDT.c
  group etDisplay
    ../../../etDisplay/: etFontApp.c etLcdDisplayApp.c etMainLoop.c etMultiPageDisplay.c etUtf8ToUnicode.c etWorkMod.c et_font_spi.c GT24L16M1Y20-518221552.lib
  group etAlgSrc
    ../../../etAlgSrc/: app_arithmetic.c arithmetic.c arithmetic_data_manger.c common_arithmetic.c data_manger.c data_transfer.c free_notic.c gSensor.c gSensor_driver.c sleep_record.c sleep_analysis.c sleep_data.c
  group etAlgSystem
    ../../../etAlgSystem/: etAlarm.c ke_timer.c usr_task.c
  group etInclude
    ../../../etInclude/: et_define.h et_inc.h et_flash_offset.h
  group etProtocol
    ../../../etProtocol/: btProtocol.c uartProtocol.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
